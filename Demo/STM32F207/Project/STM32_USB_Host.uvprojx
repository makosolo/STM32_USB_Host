# Keil uVision project STM32_USB_Host.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F207ZETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_USB_Host +hex
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_USB_OTG_FS
  c include: ..\Core;..\STM32_LIB\inc;..\STM32_USB_LIB\STM32_USB_OTG_Driver\inc;..\STM32_USB_LIB\STM32_USB_HOST_Library\Core\inc;..\STM32_USB_LIB\STM32_USB_HOST_Library\Class\MSC\inc;..\STM32_USB_LIB\USB_APP\inc;..\FAT_FS\inc;..\FAT_FS\fatfs_usr;..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\usart;..\HARDWARE;..\HARDWARE\key;..\HARDWARE\led;..\HARDWARE\flash;..\HARDWARE\stm_flash;..\Project
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Core
    ../Core/: system_stm32f2xx.c core_cm3.c
  group StartUp
    ../StartUp/: startup_stm32f2xx.s
  group STM32_LIB
    ../STM32_LIB/src/: misc.c stm32f2xx_crc.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_pwr.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_rtc.c
  group USER
    ./: main.c
    ../HARDWARE/: HW_Init.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/led/: led.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/flash/: flash.c
  group USB Host
    ../STM32_USB_LIB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
    ../STM32_USB_LIB/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
    ../STM32_USB_LIB/STM32_USB_HOST_Library/Core/src/: usbh_hcs.c usbh_ioreq.c usbh_stdreq.c usbh_core.c
  group USB_App
    ../STM32_USB_LIB/USB_APP/scr/: usb_bsp.c usbh_usr.c
    ../STM32_USB_LIB/USB_APP/inc/: lcd_log.h
  group FAT FS
    ../FAT_FS/src/: ff.c
    ../FAT_FS/fatfs_usr/: fatfs_usr.c
  group Doc
    ../Doc/: Readme.txt
